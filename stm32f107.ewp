# IAR project stm32f107.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL
  ICCARM.CCIncludePath2: ; User; SD\; SD\FATFS; LCD_driver; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: stm32f107.srec
  ILINK.IlinkOutputFile: stm32f107.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\44\桌面\STM32F10x_StdPeriph_Lib_V3.2.0\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group LCD
    LCD_driver/: AsciiLib_65k.c CN16.c ili9320.c ili9320_api.c ili932x.c touch.c
  group SD
    SD/FATFS/: diskio.c ff.c
    SD/: RTC_Time.c SPI_SD_driver.c USART_printp.c
  group STARTUP
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
  group STM32F10x_StdPeriph_Lib_V3.2.0
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    User/: main.c
